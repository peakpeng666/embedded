# Keil uVision project lab1.uvprojx, settings and files
target Lab1 STM32L496 - Keil (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L496VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IROM(0x08010000,0x70000) IRAM(0x20000000,0xF000) CPUTYPE("Cortex-M4") CLOCK(16000000) ELITTLE
  output: lab1_keil +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx
  c include: ..\lab1\src;..\lab1\vendor\st;..\lab1\vendor\arm
  asm include: ..\lab1\src;..\lab1\vendor\st;..\lab1\vendor\arm
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0xf000
  scatter file: .\lab1.sct
  link misc: --entry Reset_Handler
  group Application
    ../lab1/src/: main.c lab_logic.c lab_logic.h runtime.c
  group Startup and memory
    ./: startup_keil.s lab1.sct
  group Documentation
    ../: README.md
    ../docs/: windows.md
